## fw/sdkconfig.defaults
```kconfig
# Target: set via idf.py set-target
# CONFIG_IDF_TARGET="esp32"

CONFIG_FREERTOS_HZ=100
CONFIG_COMPILER_OPTIMIZATION_SIZE=y
CONFIG_LOG_DEFAULT_LEVEL_INFO=y
```
